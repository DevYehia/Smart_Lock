# Keil uVision project smartLock.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: smartLock
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group
    ./: main.c
  group HAL
    ./HAL/: BLUETOOTH.h BLUETOOTH.c ULTRASONIC.h ULTRASONIC.c BUZZER.c BUZZER.h
  group MCAL
    ./MCAL/: DIO.h DIO.c INTERRUPT.h INTERRUPT.c SYSTICKTimer.h SYSTICKTimer.c TIMERS.h TIMERS.c UART.h UART.c
  group LIB
    ./LIB/: bitwise_operation.h tm4c123gh6pm.h types.h
